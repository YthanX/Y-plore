# Keil uVision project STM32F103RCT6_BeatFrequency.uvprojx, settings and files
target STM32F103RCT6_BeatFrequency (5060960::V5.06 update 7 for Certification (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: STM32F103RCT6_BeatFrequency
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .;start;user;library;system;hardware;.cmsis\include;RTE\_Target 1;hardware\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.h beat_app.c beat_app.h beat_display.c beat_display.h beat_project_config.h
  group hardware
    hardware/: led.c led.h OLED_I2C.c OLED_I2C.h codetab.h key.c key.h usart.h usart.c beat_engine.c beat_engine.h encoder.c encoder.h oled_canvas.c oled_canvas.h beat_fifo.c beat_fifo.h beat_chinese_font.c beat_chinese_font.h
  group hardware/LCD
    hardware/LCD/: bmp.h lcd.h stm32_adafruit_lcd.c stm32_adafruit_lcd.h
  group hardware/LCD/Fonts
    hardware/LCD/Fonts/: font8.c font12.c font16.c font20.c font24.c fonts.h
  group hardware/LCD/lcd
    hardware/LCD/lcd/ili9341/: ili9341.c ili9341.h
  group hardware/LCD/stm32f1xx
    hardware/LCD/stm32f1xx/: lcd_io_gpio16.c lcd_io_gpio16.h
  group system
    system/: Delay.c Delay.h
  group libraries
    library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group start
    start/: startup_stm32f10x_hd.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
